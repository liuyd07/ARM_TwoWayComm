# Keil uVision project test.uvproj, settings and files
target Serial485 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Serial485 +hex
  c flags: Optim=1
  c include: .\Lib;.\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s cortexm3_macro.s
  group Source
    ./Source/: main.c serial.c ammeter_cmd.c rfcomm.c CPESchipdef.c dscomm.c
  group Lib
    ./Lib/: stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_nvic.c
  group Header
    ./Source/: ammeter_cmd.h dscomm.h CPESchipdef.h rfcomm.h serial.h
